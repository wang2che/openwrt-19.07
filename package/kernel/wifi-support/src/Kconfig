## package/kernel/wifi-support/src/Kconfig
```kconfig
config WIFI-SUPPORT
	tristate "Custom wifi-support driver"
	help
	  will be called wifi-support.
```
